inherit distro_features_check
