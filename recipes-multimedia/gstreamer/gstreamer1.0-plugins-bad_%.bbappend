PACKAGECONFIG_append = " kms"
