PACKAGECONFIG_append = " bat "
