PACKAGECONFIG_append_tqma65xx = " bat"
