# SPDX-License-Identifier: MIT
# SPDX-FileCopyrightText: Copyright (C) 2026 TQ-Systems GmbH <oss@ew.tq-group.com>

# u-boot-lsdk-tq is the TQ-maintained NXP QorIQ/Layerscape U-Boot fork
# (based on NXP LSDK). Its BPN ("u-boot-lsdk-tq") is unknown in the NVD;
# map it to the canonical upstream name so that CVE lookups work correctly.
CVE_PRODUCT = "denx:u-boot"
