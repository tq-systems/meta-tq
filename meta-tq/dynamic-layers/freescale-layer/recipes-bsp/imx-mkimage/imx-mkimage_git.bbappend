# SPDX-License-Identifier: MIT
#
# Copyright (c) 2024 TQ-Systems GmbH <oss@ew.tq-group.com>,
# D-82229 Seefeld, Germany.

# overwrite meta-freescale SRC_URI
require imx-mkimage-tq_git.inc
