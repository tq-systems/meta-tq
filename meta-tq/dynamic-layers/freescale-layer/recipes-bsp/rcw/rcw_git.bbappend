SRC_URI = "${TQ_GIT_BASEURL}/rcw.git;protocol=${TQ_GIT_PROTOCOL};branch=${SRCBRANCH}"
SRCBRANCH = "TQMLS-Integration"
SRCREV = "632c284589de624ef2f68cdc7b6e300ffd0d474e"
LIC_FILES_CHKSUM = "file://LICENSE;md5=44a0d0fad189770cc022af4ac6262cbe"

M:tqmls1012al = "tqmls1012al"
M:tqmls102xa = "tqmls1021a"
M:tqmls1028a = "tqmls1028a"
M:tqmls1043a = "tqmls1043a"
M:tqmls1046a = "tqmls1046a"
M:tqmls1088a = "tqmls1088a"
M:tqmlx2160a = "tqmlx2160a"
M:tqmt1024 = "tqmt1024"
M:tqmt1040 = "tqmt1040"
M:tqmt1042 = "tqmt1042"
M:tqmt1022 = "tqmt1042"
