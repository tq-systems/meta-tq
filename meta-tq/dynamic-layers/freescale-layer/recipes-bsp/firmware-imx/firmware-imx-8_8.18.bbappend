COMPATIBLE_MACHINE                  = "(mx8-generic-bsp|mx9-generic-bsp)"
COMPATIBLE_MACHINE:mx8m-generic-bsp = "(^$)"
COMPATIBLE_MACHINE:mx8x-generic-bsp = "(^$)"
