FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ipu-uapi-Fixed-size-integer-types-are-define-since-C.patch"

