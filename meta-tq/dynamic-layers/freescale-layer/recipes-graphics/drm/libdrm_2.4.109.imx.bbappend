# new version from meta-imx, this is the version tested by NXP for imx93 EVK
# (although the new commits are not explicitely for imx93)
# This should go to meta-freescale

IMX_LIBDRM_SRC = "git://github.com/nxp-imx/libdrm-imx.git;protocol=https;nobranch=1"
SRCREV = "063bd699054866852ae182d2b31d4d3e7eae4f03"
