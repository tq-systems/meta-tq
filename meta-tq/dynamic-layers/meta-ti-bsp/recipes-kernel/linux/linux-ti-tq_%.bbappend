# SPDX-License-Identifier: MIT
# SPDX-FileCopyrightText: Copyright (C) 2026 TQ-Systems GmbH <oss@ew.tq-group.com>

# linux-ti-tq is the TQ-maintained TI Linux kernel fork.
# Its BPN ("linux-ti-tq") is unknown in the NVD; map it to the canonical
# upstream CPE so that CVE lookups match NVD entries.
CVE_PRODUCT = "linux:linux_kernel"
