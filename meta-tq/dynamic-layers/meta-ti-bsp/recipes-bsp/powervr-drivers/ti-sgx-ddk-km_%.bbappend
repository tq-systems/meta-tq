TARGET_PRIMARY_ARCH = "target_armhf"
TARGET_PRIMARY_ARCH:aarch64 = "target_aarch64"

EXTRA_OEMAKE += "TARGET_PRIMARY_ARCH=${TARGET_PRIMARY_ARCH}"
