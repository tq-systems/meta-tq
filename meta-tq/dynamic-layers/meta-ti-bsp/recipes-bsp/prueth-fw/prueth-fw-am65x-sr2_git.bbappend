TI_LINUX_FW_SRCREV:tqma65xx = "f3d2c7cafc906adc9a2f4543aa2fee556483545d"
PRUETH_FW_AM65X_SR2_VERSION:tqma65xx = "02.02.09.03"
COMPATIBLE_MACHINE .= "|tqma65xx"
