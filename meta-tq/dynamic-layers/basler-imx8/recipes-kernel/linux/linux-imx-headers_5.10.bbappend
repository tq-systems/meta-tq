# Patches to linux-imx-headers frombasler-imx8 layer require this '5.10.72-2.2.0' relase
# or patches won't apply. Although the patches are complety unrelated to UAPI headers
SRCREV = "a68e31b63f864ff71cd4adb40fbc9e1edc75c250"
