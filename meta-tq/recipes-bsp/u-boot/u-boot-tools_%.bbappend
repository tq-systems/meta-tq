FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "\
    file://0001-tools-pblimage-allow-to-use-rcw-files-in-binary-form.patch \
"
