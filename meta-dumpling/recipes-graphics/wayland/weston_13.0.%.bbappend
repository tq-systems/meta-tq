FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Revert-require-GL_EXT_unpack_subimage-commit.patch"
