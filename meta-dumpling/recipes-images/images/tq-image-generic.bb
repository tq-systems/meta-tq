require recipes-core/images/core-image-minimal.bb
require tq-image.inc

SUMMARY =  "This is a generic image for TQ SOM with some test features."

DESCRIPTION = "Demo image based on core-image-minimal, the base for a \
booting system and essential packages for the machine. This creates a medium sized image \
and includes also test tools, not directly suitable for production - \
also from the aspect of security."

LICENSE = "MIT"
