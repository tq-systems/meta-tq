# SPDX-License-Identifier: MIT

# Copyright (c) 2023 TQ-Systems GmbH <oss@ew.tq-group.com>,
# D-82229 Seefeld, Germany.
# Author: Markus Niebel

PACKAGECONFIG:append:class-target = " examples"
