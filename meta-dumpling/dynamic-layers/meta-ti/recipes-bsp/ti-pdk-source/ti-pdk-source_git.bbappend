# need to overwrite, since problems in corporate networks
TI_PDK_GIT_PROTOCOL = "https"
TI_PDK_GIT_URI = "git://git.ti.com/git/processor-sdk/pdk.git"

#TI_PDK_GIT_PROTOCOL = "http"
