do_fetch[depends] += "debianutils:do_fetch"
