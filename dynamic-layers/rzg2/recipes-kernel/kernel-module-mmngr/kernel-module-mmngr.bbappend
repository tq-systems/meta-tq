MMNGR_CFG_tqmarzg2x = "MMNGR_SALVATORX"
