FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = "\
  file://0001-compilers-add-aarch64-tq-linux-as-link-to-aarch64-po.patch \
"
