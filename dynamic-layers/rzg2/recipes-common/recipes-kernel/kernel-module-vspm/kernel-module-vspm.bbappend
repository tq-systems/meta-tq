FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-rcar_gen3-use-src-variable-from-kernel-in-include-pa.patch"
