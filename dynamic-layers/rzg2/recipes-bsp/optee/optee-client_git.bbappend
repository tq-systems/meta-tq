#FILESEXTRAPATHS_append = "${BSPDIR}/sources/meta-rzg2/recipes-bsp/optee/optee-client:"

COMPATIBLE_MACHINE_append = "|tqmarzg2x"
