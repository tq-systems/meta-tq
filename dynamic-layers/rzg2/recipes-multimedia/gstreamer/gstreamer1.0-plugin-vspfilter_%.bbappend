FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

VSPFILTER_CONF_r8a774a1 = "gstvspfilter-${MACHINE}_r8a774a1.conf"
VSPFILTER_CONF_r8a774b1 = "gstvspfilter-${MACHINE}_r8a774b1.conf"
VSPFILTER_CONF_r8a774c0 = "gstvspfilter-${MACHINE}_r8a774c0.conf"
VSPFILTER_CONF_r8a774e1 = "gstvspfilter-${MACHINE}_r8a774e1.conf"
