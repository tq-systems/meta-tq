FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append := " file://0001-add-sys-sysmacros.h.patch"
