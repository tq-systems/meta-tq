# This is the currently tested version for TQMa8Mx

SRCBRANCH_tqma8mx = "imx_4.14.98_2.1.0"
SRCREV_tqma8mx = "727cf896a4c79d152dae4537e28400c747bf39b9"

SRCBRANCH_tqma8mq = "imx_4.14.98_2.1.0"
SRCREV_tqma8mq = "727cf896a4c79d152dae4537e28400c747bf39b9"
