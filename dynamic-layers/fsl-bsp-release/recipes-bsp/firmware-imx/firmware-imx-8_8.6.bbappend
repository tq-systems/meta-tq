COMPATIBLE_MACHINE_mx8m = ""
COMPATIBLE_MACHINE_mx8x = ""
COMPATIBLE_MACHINE      = "mx8"
