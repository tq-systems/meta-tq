COMPATIBLE_MACHINE .= "|tqma57xx"

TARGET:tqma57xx= "am57xx-pru0-prueth-fw.elf am57xx-pru1-prueth-fw.elf"

PRU_VERSION:tqma57xx = "REV2"

FW_PREFIX:tqma57xx = "am57xx"
