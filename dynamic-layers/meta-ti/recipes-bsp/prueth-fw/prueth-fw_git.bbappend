COMPATIBLE_MACHINE .= "|tqma572x-mba57xx"

TARGET_tqma572x-mba57xx = "am57xx-pru0-prueth-fw.elf am57xx-pru1-prueth-fw.elf"
