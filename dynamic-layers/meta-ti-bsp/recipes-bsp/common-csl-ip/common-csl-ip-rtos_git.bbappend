FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://doxyfile-build-fix.patch"
