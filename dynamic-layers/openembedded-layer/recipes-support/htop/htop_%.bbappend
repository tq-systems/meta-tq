PACKAGECONFIG_remove_libc-musl = "unicode"
