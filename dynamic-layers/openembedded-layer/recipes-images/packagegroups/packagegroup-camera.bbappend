RDEPENDS_${PN} += "\
    yavta \
    v4l-utils \
"
