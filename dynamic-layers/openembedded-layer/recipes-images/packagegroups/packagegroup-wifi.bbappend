RDEPENDS_${PN} += "\
    hostapd \
"
