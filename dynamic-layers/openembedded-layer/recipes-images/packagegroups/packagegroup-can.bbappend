RDEPENDS_${PN}_append = " \
    can-utils \
"
