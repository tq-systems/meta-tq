RDEPENDS_${PN}_append = "\
    spitools \
    lmsensors-libsensors \
    lmsensors-sensors \
    libgpiod \
"
