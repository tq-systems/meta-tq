RDEPENDS_${PN}_append = " \
    iperf2 \
    iperf3 \
"
