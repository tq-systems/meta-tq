RDEPENDS_${PN}_append = " \
    linuxptp \
    cpufrequtils \
"
