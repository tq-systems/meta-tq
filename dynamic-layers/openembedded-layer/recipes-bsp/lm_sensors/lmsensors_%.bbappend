# remove rrdtool / sensord
# otherwise this causes a complex dependency chain (rddtool / pango / cairo / gles)

PACKAGECONFIG ?= ""

