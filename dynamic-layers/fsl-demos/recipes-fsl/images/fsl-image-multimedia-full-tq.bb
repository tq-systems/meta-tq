# extends fsl-image-multimedia-full with additional tools

LICENSE = "MIT"

require recipes-fsl/images/fsl-image-multimedia-full.bb
require fsl_image_append.inc
