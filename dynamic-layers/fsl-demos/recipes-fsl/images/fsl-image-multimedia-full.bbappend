# extends fsl-image-multimedia-full with additional tools

require fsl_image_append.inc
