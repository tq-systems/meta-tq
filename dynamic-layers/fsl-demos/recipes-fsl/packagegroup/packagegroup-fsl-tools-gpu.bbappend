SOC_TOOLS_GPU_remove_imxgpu   = " imx-gpu-sdk"
