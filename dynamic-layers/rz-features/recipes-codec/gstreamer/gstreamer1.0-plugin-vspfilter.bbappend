FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_tqmarzg2h = "tqmarzg2h-mbarzg2x"
COMPATIBLE_MACHINE_tqmarzg2m = "tqmarzg2m-mbarzg2x"
COMPATIBLE_MACHINE_tqmarzg2n = "tqmarzg2n-mbarzg2x"
