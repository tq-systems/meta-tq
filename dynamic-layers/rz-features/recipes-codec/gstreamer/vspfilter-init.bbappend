COMPATIBLE_MACHINE .= "|tqmarzg2x"
