PACKAGECONFIG_append_class-target = " examples"
