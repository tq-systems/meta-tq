DEPENDS_append_mx8 = " imx-boot-mfgtool"
