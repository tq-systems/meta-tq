IMAGE_INSTALL_append_use-nxp-bsp = "\
    packagegroup-imx-gstreamer \
"
