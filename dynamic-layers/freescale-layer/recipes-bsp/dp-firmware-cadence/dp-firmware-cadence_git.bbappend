# Work around https://github.com/Freescale/meta-freescale/issues/360
LICENSE = "Proprietary"
