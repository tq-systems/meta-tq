# we're on top of meta-freescale, multi board support is broken, when
# fiddling with RECIPE_SYSROOT
# restore defaults

RECIPE_SYSROOT = "${WORKDIR}/recipe-sysroot"
RECIPE_SYSROOT_NATIVE = "${WORKDIR}/recipe-sysroot-native"

