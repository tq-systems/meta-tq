FILESEXTRAPATHS_prepend_imxfbdev := "${THISDIR}/${BPN}/imxfbdev:"

INI_UNCOMMENT_ASSIGNMENTS_append_mx6 = " \
    use-g2d=1 \
"
