# just a dirty hack ...
PROVIDES += "virtual/mfgtool-${TARGET_PREFIX}binutils"
