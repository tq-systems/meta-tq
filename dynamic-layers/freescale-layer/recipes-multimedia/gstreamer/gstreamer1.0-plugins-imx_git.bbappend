PACKAGECONFIG[g2d] = ",--disable-g2d,virtual/libg2d"
