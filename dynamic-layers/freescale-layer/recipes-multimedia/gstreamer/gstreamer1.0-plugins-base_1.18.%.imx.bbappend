FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "\
    file://0001-glupload-Do-not-hard-code-RGBA-format-for-sink-pad.patch \
"
