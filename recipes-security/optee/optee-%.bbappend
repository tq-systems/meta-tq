COMPATIBLE_MACHINE_ti-soc = "ti-soc"

DEPENDS += "python3-native"
DEPENDS += "python3-pyelftools-native"
DEPENDS += "python3-pycryptodomex-native"
