require u-boot-imx-tq-common_${PV}.inc
require u-boot-fw-utils-common.inc
