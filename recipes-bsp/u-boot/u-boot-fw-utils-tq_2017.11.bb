require u-boot-tq-common_${PV}.inc
require u-boot-fw-utils-common.inc
