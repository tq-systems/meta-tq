require u-boot-tq-imx-common_${PV}.inc
require u-boot-fw-utils-common.inc
