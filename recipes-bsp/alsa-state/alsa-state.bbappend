# Append path for tq layer to include alsa-state asound.conf
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
