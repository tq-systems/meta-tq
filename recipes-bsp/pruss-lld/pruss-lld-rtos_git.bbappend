COMPATIBLE_MACHINE_append = "|tqma65xx"
