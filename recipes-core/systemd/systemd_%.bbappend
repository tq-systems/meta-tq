RDEPENDS_${PN} += "systemd-machine-units"
